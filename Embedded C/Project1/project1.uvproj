# Keil uVision project project1.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: LPC1768 NXP
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x2007C000-0x20083FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: project1 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c include: E:\Keil\C51\INC;E:\Keil\C51\BIN;E:\Keil\C51\LIB;E:\Keil\C51;E:\Keil\ARM
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
